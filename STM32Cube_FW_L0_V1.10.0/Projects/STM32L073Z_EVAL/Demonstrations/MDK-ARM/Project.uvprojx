# Keil uVision project Project.uvprojx, settings and files
target STM32L073Z_EVAL_Demo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L073VZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L073Z_EVAL_Demo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L073xx,USE_STM32L073Z_EVAL,USE_FULL_ASSERT
  c misc: --C99
  c include: ../Modules/main_app;../Modules/thermometer;../Modules/low_power;../Modules/lpuart_wakeup;../Modules/pressure;../Modules/lc_sensor_metering;../Modules/help_app;../Demo/Inc;../Core/Inc;../Config;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32L073Z_EVAL;../../../../Drivers/BSP/Components;../../../../Drivers/BSP/Components/Common;../../../../Middlewares/Third_Party/FatFs/src;../../../../Middlewares/Third_Party/FatFs/src/drivers
  asm include: ROJ_DIR$\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Demo/Modules/LcSensorMetering
    ../Modules/lc_sensor_metering/: lc_sensor_metering_app.c
  group Demo/Modules/Main_App
    ../Modules/main_app/: main_app.c
  group Middlewares/FatFs/Options
    ../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Drivers/CMSIS
    ../Demo/Src/: system_stm32l0xx.c
  group Demo/Modules/LowPower
    ../Modules/low_power/: lowpower_app.c
  group Drivers/STM32L0xx_HAL_Drivers
    ../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_gpio.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rcc.c stm32l0xx_hal_usart.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_i2c.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_i2s.c stm32l0xx_hal_flash.c stm32l0xx_hal_smbus.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_adc.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_cortex.c stm32l0xx_hal_irda.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_comp.c stm32l0xx_hal.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_wwdg.c
  group Demo/Core
    ../Core/Src/: k_module.c k_storage.c k_window.c k_menu.c k_demo.c k_tools.c
  group Demo/Modules/Pressure
    ../Modules/pressure/: histogram.c pressure_app.c
  group Application/User
    ../Demo/Src/: stm32l0xx_it.c main.c
  group Demo/Modules/LpUartWakeup
    ../Modules/lpuart_wakeup/: lpuart_wakeup_app.c
  group Doc
    ../: readme.txt
  group Demo/Modules/Help
    ../Modules/help_app/: help_app.c
  group Demo/Modules/thermometer
    ../Modules/thermometer/: thermometer_app.c stm32l0xx_tsensor.c
  group Application/MDK-ARM
    ./: startup_stm32l073xx.s
  group Drivers/BSP/Component
    ../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../../Drivers/BSP/Components/stlm75/: stlm75.c
  group Middlewares/FatFs/Core
    ../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
  group Middlewares/FatFs/Drivers
    ../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Drivers/BSP/STM32L073Z_EVAL
    ../../../../Drivers/BSP/STM32L073Z_EVAL/: stm32l073z_eval_sd.c stm32l073z_eval_tsensor.c stm32l073z_eval_io.c stm32l073z_eval.c stm32l073z_eval_idd.c stm32l073z_eval_lcd.c
software components: CMSIS:CORE 4.3.0
