# IAR project Project.ewp, settings and files
configuration STM32L073Z_EVAL_Demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32L073VZ ST STM32L073VZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L073xx; USE_STM32L073Z_EVAL; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ..\Modules\main_app; ..\Modules\thermometer; ..\Modules\low_power; ..\Modules\lpuart_wakeup; ..\Modules\pressure; ..\Modules\lc_sensor_metering; ..\Modules\help_app; ..\Demo\Inc; ..\Core\Inc; ..\Config; ..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\Drivers\BSP\STM32L073Z_EVAL; ..\..\..\..\Drivers\BSP\Components; ..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: STM32CubeL0_Demo_STM32L073Z_EVAL.hex
  ILINK.IlinkOutputFile: STM32L073VZ_EVAL_DEMO.out
  ILINK.IlinkIcfFile: stm32l073xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l073xx.s
  group Application/User
    ../Demo/Src/: main.c stm32l0xx_it.c
  group Demo/Core
    ../Core/Src/: k_demo.c k_menu.c k_module.c k_storage.c k_tools.c k_window.c
  group Demo/Modules/Help
    ../Modules/help_app/: help_app.c
  group Demo/Modules/LcSensorMetering
    ../Modules/lc_sensor_metering/: lc_sensor_metering_app.c
  group Demo/Modules/LowPower
    ../Modules/low_power/: lowpower_app.c
  group Demo/Modules/LpUartWakeup
    ../Modules/lpuart_wakeup/: lpuart_wakeup_app.c
  group Demo/Modules/Main_App
    ../Modules/main_app/: main_app.c
  group Demo/Modules/Pressure
    ../Modules/pressure/: histogram.c pressure_app.c
  group Demo/Modules/thermometer
    ../Modules/thermometer/: stm32l0xx_tsensor.c thermometer_app.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Component
    ../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../Drivers/BSP/Components/stlm75/: stlm75.c
  group Drivers/BSP/STM32L073Z_EVAL
    ../../../../Drivers/BSP/STM32L073Z_EVAL/: stm32l073z_eval.c stm32l073z_eval_idd.c stm32l073z_eval_io.c stm32l073z_eval_lcd.c stm32l073z_eval_sd.c stm32l073z_eval_tsensor.c
  group Drivers/CMSIS
    ../Demo/Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Drivers
    ../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c
  group Middlewares/FatFs/Core
    ../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/FatFs/Options
    ../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
