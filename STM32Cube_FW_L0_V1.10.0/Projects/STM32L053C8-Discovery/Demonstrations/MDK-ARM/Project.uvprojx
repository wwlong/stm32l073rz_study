# Keil uVision project Project.uvprojx, settings and files
target STM32L0538-Discovery (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L053C8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L0538-Discovery
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L053xx,USE_STM32L0538_DISCO
  c misc: --C99
  c include: ../Core/Inc;../Config;../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32L0538-Discovery;../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc;../../../../Middlewares/ST/STM32_TouchSensing_Library/inc;../../../../Drivers/BSP/Components;../../../../Drivers/BSP/Components/Common
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/User/Modules/IddMeasurement
    ../Modules/iddmeasurement/: power.c
  group Drivers/BSP/STM32L0538-Discovery
    ../../../../Drivers/BSP/STM32L0538-Discovery/: stm32l0538_discovery_epd.c stm32l0538_discovery.c
  group Middlewares/TouchSensing_Library
    ../../../../Middlewares/ST/STM32_TouchSensing_Library/src/: tsl_object.c tsl_filter.c tsl_time.c tsl_acq_tsc.c tsl_touchkey.c tsl.c tsl_ecs.c tsl_linrot.c tsl_globals.c tsl_dxs.c tsl_acq.c
  group Application/User/Modules/USBHID
    ../Modules/usbHID/: usbdapp.c usbd_conf.c usbd_desc.c
  group Application/MDK-ARM
    ./: startup_stm32l053xx.s
  group Drivers/BSP/Compnents
    ../../../../Drivers/BSP/Components/gde021a1/: gde021a1.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Application/User/Core
    ../Core/Src/: main.c stm32l0xx_hal_msp.c tsl_user.c menu.c bsp.c stm32l0xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_rcc.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_flash.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_dma.c stm32l0xx_hal_tsc.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_cortex.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_pcd.c
  group Middlewares/USBD_Library/Class/HID
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Middlewares/USBD_Library/Core
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
software components: CMSIS:CORE 4.3.0
